# Keil uVision project EEPROM.uvproj, settings and files
target UART1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: EEPROM +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\Include;.\Source
  group Source
    ./Source/: includes.h STARTUP.A51 main.c Common.c Delay.c I2C_S.c I2C_SS.c Table.c TPS23861.c FLASH_EEPROM.c
  group TXT
    ./: SoftwareVersionRecording.txt
